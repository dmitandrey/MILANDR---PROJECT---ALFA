# Keil uVision project UART+DAC.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.2.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UART+DAC
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: C:\Users\dmita\AppData\Local\Keil_v5\ARM\PACK\NordicSemiconductor\Config;C:\Users\dmita\AppData\Local\Keil_v5\ARM\PACK\NordicSemiconductor\RTT
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c
  group SEGGER
    C:/Users/dmita/AppData/Local/Keil_v5/ARM/PACK/NordicSemiconductor/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group libs
    ./: vars_and_const.c clock.c port.c uart.c dac.c interrupts.c
  group LCD
    ./: LCD.h LCD.c port_LCD.c pins.c pins.h
software components: Device:Startup 2.1.0i, Drivers:DAC 2.1.0i, Drivers:PORT 2.1.0i, Drivers:RST_CLK 2.1.0i, Drivers:UART 2.2.0i
